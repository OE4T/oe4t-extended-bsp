FWDEPS:append:tegra194 = " tegra-firmware-gv11b"
