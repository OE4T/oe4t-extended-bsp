RRECOMMENDS:${PN}:tegra194 = "kernel-module-tegra-drm"
